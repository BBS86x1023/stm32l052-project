# Keil uVision project Skill_Competition_Region_48.uvprojx, settings and files
target Skill_Competition_Region_48 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L052R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Skill_Competition_Region_48
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L052xx
  c include: ../Inc;     C:/Users/BBS/STM32Cube/Repository/STM32Cube_FW_L0_V1.10.0/Drivers/STM32L0xx_HAL_Driver/Inc;     C:/Users/BBS/STM32Cube/Repository/STM32Cube_FW_L0_V1.10.0/Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;     C:/Users/BBS/STM32Cube/Repository/STM32Cube_FW_L0_V1.10.0/Drivers/CMSIS/Device/ST/STM32L0xx/Include;     C:/Users/BBS/STM32Cube/Repository/STM32Cube_FW_L0_V1.10.0/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l052xx.s
  group Drivers/STM32L0xx_HAL_Driver
    C:/Users/BBS/STM32Cube/Repository/STM32Cube_FW_L0_V1.10.0/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal.c stm32l0xx_hal_tim.c stm32l0xx_hal_pwr.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32l0xx.c
  group Application/User
    ../Src/: stm32l0xx_hal_msp.c main.c stm32l0xx_it.c
software components: CMSIS:CORE 4.3.0
